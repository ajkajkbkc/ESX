# Keil uVision project Kalyke_Master.uvprojx, settings and files
target lwip_mqtt_freertos debug (6180000::V6.18::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lwip_mqtt_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1062DVL6A, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: board;source;CMSIS;component/lists;component/serial_manager;component/uart;device;drivers;freertos/freertos_kernel/include;freertos/freertos_kernel/portable/GCC/ARM_CM4F;lwip/port;lwip/port/arch;lwip/src;lwip/src/include;lwip/src/include/compat/posix;lwip/src/include/compat/posix/arpa;lwip/src/include/compat/posix/net;lwip/src/include/compat/posix/sys;lwip/src/include/compat/stdc;lwip/src/include/lwip;lwip/src/include/lwip/apps;lwip/src/include/lwip/priv;lwip/src/include/lwip/prot;lwip/src/include/netif;lwip/src/include/netif/ppp;lwip/src/include/netif/ppp/polarssl;mdio;phy;startup;utilities;xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: --remove --predefine="-D__stack_size__=1000" --predefine="-D__heap_size__=25600"
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
    ./board/: sdmmc_config.c sdmmc_config.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/osa
    ./component/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: lpuart_adapter.c uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_enet.c fsl_enet.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
    ./drivers/: fsl_flexspi.c fsl_flexspi.h fsl_gpt.c fsl_gpt.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_freertos.c fsl_lpi2c_freertos.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_freertos.c fsl_lpspi_freertos.h fsl_lpuart_freertos.c fsl_lpuart_freertos.h fsl_ocotp.c fsl_ocotp.h fsl_pit.c fsl_pit.h fsl_qtmr.c fsl_qtmr.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pwm.c fsl_pwm.h fsl_xbara.c fsl_xbara.h
  group freertos/freertos_kernel
    freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable/GCC/ARM_CM4F
    freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ./freertos/freertos_kernel/portable/MemMang/: heap_4.c
  group freertos/freertos_kernel/portable
    freertos/freertos_kernel/portable/: readme.txt
  group lwip
    lwip/: ChangeLogKSDK.txt CMakeLists.txt
  group lwip/doc
    lwip/doc/: contrib.txt mdns.txt mqtt_client.txt NO_SYS_SampleCode.c ppp.txt savannah.txt ZeroCopyRx.c
  group lwip/doc/doxygen
    lwip/doc/doxygen/: main_page.h
  group lwip/doc/doxygen/output
    lwip/doc/doxygen/output/: index.html
  group lwip/port/arch
    lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/port
    lwip/port/: enet_ethernetif.c enet_ethernetif.h enet_ethernetif_kinetis.c enet_ethernetif_priv.h sys_arch.c
  group lwip/src/api
    lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/apps/mqtt
    lwip/src/apps/mqtt/: mqtt.c
  group lwip/src/apps/sntp
    ./lwip/src/apps/sntp/: sntp.c
  group lwip/src/core
    lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix/arpa
    lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix
    lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/sys
    lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/apps
    lwip/src/include/lwip/apps/: mqtt.h mqtt_opts.h mqtt_priv.h
  group lwip/src/include/lwip/priv
    lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    lwip/src/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/netif/ppp/polarssl
    lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group mdio
    mdio/: fsl_enet_mdio.c fsl_enet_mdio.h fsl_mdio.h
  group phy
    phy/: fsl_phy.h fsl_phyksz8081.c fsl_phyksz8081.h
  group startup
    startup/: startup_MIMXRT1062.S
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group xip
    xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group OTA
    ./OTA/: kalyke_ota.c kalyke_ota.h
  group source
    source/: FreeRTOSConfig.h lwip_mqtt_id.h lwip_mqtt_id_otp.c lwipopts.h
    ./source/: main.c main.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
  group source/kalyke
    ./source/kalyke/: kalyke_4G_task.c kalyke_4G_task.h kalyke_4G_TCP_task.c kalyke_4G_TCP_task.h kalyke_ad_task.c kalyke_ad_task.h kalyke_event.c kalyke_event.h kalyke_internet_task.c kalyke_internet_task.h kalyke_led_task.c kalyke_led_task.h kalyke_monitor_task.c kalyke_monitor_task.h kalyke_opts.h kalyke_sd_card_task.c kalyke_sd_card_task.h kalyke_sntp_task.c kalyke_sntp_task.h kalyke_uart_task.c kalyke_uart_task.h kalyke_usb_task.c kalyke_usb_task.h kalyke_modbus_tcp.c kalyke_modbus_com.c kalyke_DS1302.c kalyke_tcp_task.c kalyke_tcp_task.h kalyke_ping_task.c kalyke_ping_task.h kalyke_oled_key_task.c kalyke_oled_key_task.h kalyke_collect_task.c kalyke_collect_task.h
  group source/tools
    ./source/tools/: jsmn.c jsmn.h kalyke_cJSON.c kalyke_cJSON.h kalyke_json.c kalyke_json.h kalyke_tool.c kalyke_tool.h kalyke_version.h
  group source/tools/cJSON
    ./source/tools/cJSON/: cJSON.c cJSON.h
  group source/common
    ./source/common/inc/: list_func.h rc6.h verify_func.h
    ./source/common/src/: rc6.c verify_func.c
  group source/plc
    ./source/plc/: plc_task.c plc_task.h
  group source/plc/common
    ./source/plc/common/inc/: plc_commonfunc.h plc_element.h plc_variable.h
    ./source/plc/common/src/: plc_commonfunc.c plc_element.c plc_variable.c
  group source/plc/executer
    ./source/plc/executer/inc/: plc_compiler.h plc_complexins.h plc_counterins.h plc_dataprocessing.h plc_errormsg.h plc_executer.h plc_externalins.h plc_flowctrlins.h plc_highspeedins.h plc_instruction.h plc_modbusins.h plc_modbustcpins.h plc_parseaddr.h plc_pid.h plc_simpleins.h plc_spd.h plc_strins.h plc_timeins.h plc_uartins.h plc_verifyins.h
    ./source/plc/executer/src/: plc_compiler.c plc_complexins.c plc_counterins.c plc_dataprocessing.c plc_executer.c plc_externalins.c plc_flowctrlins.c plc_highspeedins.c plc_modbusins.c plc_modbustcpins.c plc_parseaddr.c plc_pid.c plc_simpleins.c plc_spd.c plc_strins.c plc_timeins.c plc_uartins.c plc_verifyins.c plc_tcpins.c
  group source/plc/executer/soem
    ./source/plc/executer/src/soem/: plc_soem.c plc_soem.h
  group source/plc/executer/highspeed
    ./source/plc/executer/src/highspeed/: high_count.c high_count.h highcount_cmd.c highcount_cmd.h highspeed_int.c highspeed_int.h
  group source/plc/internal
    ./source/plc/internal/inc/: plc_internalmanage.h plsd_task.h
    ./source/plc/internal/src/: plc_internalmanage.c plsd_task.c
  group source/plc/interrupt
    ./source/plc/interrupt/inc/: plc_interrupt.h plc_io_interrupt.h
    ./source/plc/interrupt/src/: plc_interrupt.c plc_io_interrupt.c
  group source/plc/portable
    ./source/plc/portable/inc/: port_clockcycle.h
    ./source/plc/portable/src/: port_clockcycle.c
  group source/plc/sysmanage
    ./source/plc/sysmanage/inc/: plc_netcfg.h plc_password.h plc_sysblock.h plc_sysinit.h
    ./source/plc/sysmanage/src/: plc_netcfg.c plc_password.c plc_sysblock.c plc_sysinit.c
  group source/protocol/modbus
    ./source/protocol/modbus/inc/: mb.h mb_ctrl.h mb_download.h mb_maptable.h mb_upload.h
    ./source/protocol/modbus/src/: mb.c mb_ctrl.c mb_download.c mb_maptable.c mb_upload.c
  group board/bsp_1062
    ./board/bsp_1062/: bsp.c bsp.h bsp_dct.c bsp_dct.h bsp_flash.c bsp_flash.h bsp_gpio.c bsp_gpio.h bsp_iwdg.c bsp_iwdg.h bsp_led.c bsp_led.h bsp_tim.c bsp_tim.h bsp_uart.c bsp_uart.h mflash_drv.c mflash_drv.h
  group eng/dev_sign
    ./eng/dev_sign/: dev_sign_api.h dev_sign_internal.h dev_sign_mqtt.c dev_sign_wrapper.h
  group eng/infra
    ./eng/infra/: infra_defs.c infra_sha256.c
  group usb/device/class/hid
    ./usb/device/class/hid/: usb_device_hid.c
  group usb/device/class
    ./usb/device/class/: usb_device_class.c
  group usb/device/include
    ./usb/device/include/: usb_device.h
  group usb/device/source/ehci
    ./usb/device/source/ehci/: usb_device_ehci.c
  group usb/device/source
    ./usb/device/source/: usb_device_ch9.c usb_device_dci.c
  group usb/include
    ./usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ./usb/phy/: usb_phy.c
  group source/daisy
    ./source/daisy/: daisy_task.c daisy_task.h daisy_uart_task.c daisy_uart_task.h slave_smart_device.c slave_smart_device.h
  group source/EtherCAT
    ./source/EtherCAT/: ether_cat_task.c ether_cat_task.h ether_cat_list.c ether_cat_list.h
  group source/EtherCAT/SOEM/soem
    ./source/EtherCAT/SOEM/soem/: ethercatbase.c ethercatcoe.c ethercatconfig.c ethercatdc.c ethercateoe.c ethercatfoe.c ethercatmain.c ethercatprint.c ethercatsoe.c
  group source/EtherCAT/SOEM/osal
    ./source/EtherCAT/SOEM/osal/rtk/: osal.c
  group source/EtherCAT/SOEM/oshw
    ./source/EtherCAT/SOEM/oshw/rtk/: nicdrv.c oshw.c
    ./source/EtherCAT/SOEM/oshw/rtk/lw_mac/: lw_emac.c
  group sdmmc280
    ./sdmmc280/: ChangeLogKSDK.txt
  group sdmmc280/host
    ./sdmmc280/host/: fsl_sdmmc_host.c fsl_sdmmc_host.h
  group sdmmc280/inc
    ./sdmmc280/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc280/osa
    ./sdmmc280/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group sdmmc280/src
    ./sdmmc280/src/: fsl_sd.c fsl_sdmmc_common.c
  group source/pid
    ./source/pid/: pid_task.c
  group source/FlexButton
    ./source/FlexibleButton-v1.0.0/: flexible_button.c flexible_button.h
  group source/oled
    ./source/oled/: oled_codetab.c oled_codetab.h oled_i2c.c oled_i2c.h
target lwip_mqtt_freertos flexspi_nor_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lwip_mqtt_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1062DVL6A, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=1000" --predefine="-D__heap_size__=25600"
--remove
target lwip_mqtt_freertos sdram_debug (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lwip_mqtt_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, DEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1062DVL6A, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: as above
target lwip_mqtt_freertos release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lwip_mqtt_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1062DVL6A, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: as above
target kalyke_flexspi_nor_release (6180000::V6.18::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: Kalyke_Master.out +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: nSOEM_SEND_RECV_HEXDUMP, SOEM_SLAVE_USE_POINTER, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, nSD_ENABLED, ENABLE_RAM_VECTOR_TABLE, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1062DVL6A, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS, PRINTF_FLOAT_ENABLE=1, USB_STACK_FREERTOS
  c misc: as above
  c include: board;source;CMSIS;component/lists;component/serial_manager;component/uart;component/osa;device;drivers;freertos/freertos_kernel/include;freertos/freertos_kernel/portable/GCC/ARM_CM4F;lwip/port;lwip/port/arch;lwip/src;lwip/src/include;lwip/src/include/compat/posix;lwip/src/include/compat/posix/arpa;lwip/src/include/compat/posix/net;lwip/src/include/compat/posix/sys;lwip/src/include/compat/stdc;lwip/src/include/lwip;lwip/src/include/lwip/apps;lwip/src/include/lwip/priv;lwip/src/include/lwip/prot;lwip/src/include/netif;lwip/src/include/netif/ppp;lwip/src/include/netif/ppp/polarssl;mdio;phy;startup;utilities;xip;source/EtherCAT;source/EtherCAT/SOEM/soem;source/EtherCAT/SOEM/osal;source/EtherCAT/SOEM/osal/rtk;source/EtherCAT/SOEM/oshw/rtk;source/EtherCAT/SOEM/oshw/rtk/fec;source/EtherCAT/SOEM/oshw/rtk/lw_mac;source/kalyke;source/tools;source/plc;source/plc/interrupt/inc;source/plc/common/inc;source/plc/executer/inc;source/plc/executer/src/soem;source/plc/executer/src/highspeed;source/plc/internal/inc;source/plc/portable/inc;source/plc/sysmanage/inc;source/common/inc;source/protocol/modbus/inc;OTA;eng/infra;eng/dev_sign;usb/device/class;usb/device/class/hid;usb/device/include;usb/device/source;usb/device/source/ehci;usb/include;usb/phy;usb/osa;usb/kalyke;source/daisy;source/tools/cJSON;board/bsp_1062;sdmmc280/host;sdmmc280/inc;sdmmc280/osa;source/pid;.\source\FlexibleButton-v1.0.0;.\source\oled
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  memory RVCT1: ROM 0x60000000 size 0x7dc00
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-D__stack_size__=1000" --predefine="-D__heap_size__=1024" --predefine="-D__ram_vector_table__"
--remove 
--diag_suppress=6329
target lwip_mqtt_freertos sdram_release (ARM-ADS)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lwip_mqtt_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, SKIP_SYSCLK_INIT, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE, CPU_MIMXRT1062DVL6A, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_sdram.scf
  link misc: as above
